# IAR project gw-nrf.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nrf52832_xxaa NordicSemi nrf52832_xxaa
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: S132; NRF52; NRF52832_XXAA; NRF52_PAN_74; NRF_SD_BLE_API_VERSION=5
  ICCARM.CCIncludePath2: ..\sources; ..\libraries\s132_nrf52_5.0.0_API\include; ..\libraries\s132_nrf52_5.0.0_API\include\nrf52; ..\libraries\device\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: gw-nrf.srec
  ILINK.IlinkOutputFile: gw-nrf.out
  ILINK.IlinkIcfFile: nRF52832s132.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group libraries/device
    ../libraries/device/: compiler_abstraction.h nrf.h nrf51.h nrf51422_peripherals.h nrf51802_peripherals.h nrf51822_peripherals.h nrf51_bitfields.h nrf51_deprecated.h nrf51_to_nrf52.h nrf51_to_nrf52810.h nrf51_to_nrf52840.h nrf52.h nrf52810.h nrf52810_bitfields.h nrf52810_peripherals.h nrf52832_peripherals.h nrf52840.h nrf52840_bitfields.h nrf52840_peripherals.h nrf52_bitfields.h nrf52_name_change.h nrf52_to_nrf52810.h nrf52_to_nrf52840.h
  group libraries/s132_nrf52_5.0.0_API/include
    ../libraries/s132_nrf52_5.0.0_API/include/: ble.h ble_err.h ble_gap.h ble_gatt.h ble_gattc.h ble_gatts.h ble_hci.h ble_l2cap.h ble_ranges.h ble_types.h nrf_error.h nrf_error_sdm.h nrf_error_soc.h nrf_nvic.h nrf_sdm.h nrf_soc.h nrf_svc.h
  group libraries/s132_nrf52_5.0.0_API/include/nrf51
    ../libraries/s132_nrf52_5.0.0_API/include/nrf52/: nrf_mbr.h
  group sources
    ../sources/: iar_startup_nrf52.s main.c system_nrf52.c system_nrf52.h
